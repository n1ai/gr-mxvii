options:
  parameters:
    generate_options: qt_gui
    id: mxvii_encoder_example
    output_language: python
    title: MXVII Encoder Example
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: byte
  states: {}
- name: mxvii_encoder_0
  id: mxvii_encoder
  parameters:
    destination_address: Broadcast
    source_address: None
  states: {}

connections:
- [blocks_null_source_0, '0', mxvii_encoder_0, '0']
- [mxvii_encoder_0, '0', blocks_null_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.2.0
